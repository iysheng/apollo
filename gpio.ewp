# IAR project gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767IG ST STM32F767IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx
  ICCARM.CCIncludePath2: D:\Apollo\gpio\CMSIS_header; D:\Apollo\gpio\CMSIS_core; D:\Apollo\gpio\HAL_Driver\Inc; D:\Apollo\gpio; D:\Apollo\gpio\Bsp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APOLLO-BSP
    Bsp/: apollo.c
  group CMSIS-CORE
    CMSIS_core/: startup_stm32f767xx.s system_stm32f7xx.c
  group HAL-SRC
    ../../STM32Cube_FW_F7_V1.6.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c
    HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_dma.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_it.c stm32f7xx_ll_fmc.c
  group USER
    ./: main.c rgb.c touch.c
